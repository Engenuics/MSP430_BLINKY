# IAR project blink-efwd.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2122 MSP430F2122
  General.GStackSize2: 120
  General.GHeapSize2: 40
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: ..\
  XLINK.XclFile: ..\lnk430F2122_BLINK.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: blnkyeie-pcb-01.c blnkyeie-pcb-01.h cstartup.s43 io430x21x2.h main.c main.h msp430x21x2.h typedef_MSP430.h
